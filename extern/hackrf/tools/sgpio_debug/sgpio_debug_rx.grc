options:
  parameters:
    author: mike
    generate_options: qt_gui
    id: sgpio_debug_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: delay
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    sdr_stop: '256'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(20e6)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: samp_rate/256
    offset: '-1'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: float
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Adjust delay until the plot is ~0.

      There should be no intermittent spikes.
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    tr_delay: '2.56e-6'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    balance0: '0'
    center_freq0: 100.0e6
    correction0: '0'
    dc_offset0: '0'
    dc_offset_auto_mode0: 'False'
    dc_offset_auto_mode1: 'False'
    devname: hackrf
    gain_auto_mode0: 'False'
    gain_auto_mode1: 'False'
    manual_gain0: 'True'
    manual_gain1: 'True'
    mix_gain1: '10'
    overall_gain0: '10'
    samp_rate: samp_rate
    sdrplay_biastee: 'True'
    tuner_gain1: '10'
    type: fc32
    vga_gain1: '10'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_float_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0, '1', blocks_interleave_0, '1']
- [blocks_delay_0, '0', blocks_sub_xx_0, '1']
- [blocks_interleave_0, '0', blocks_sub_xx_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_source_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
